<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>am_receiver_rsp1a_testc</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>AM Receiver RSP1A TESTC</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_dec</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>5e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimate</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>freq_coarse + freq_fine + freq_offset</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_coarse</value></param>
<param><key>value</key><value>860e3</value></param>
<param><key>gui_hint</key><value>0, 1, 1, 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>520e3</value></param>
<param><key>step</key><value>5e3</value></param>
<param><key>stop</key><value>1440e3</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_fine</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0, 2, 1, 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>-30</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>passband</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>1, 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>4</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition</value></param>
<param><key>value</key><value>1.5e3</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>gui_hint</key><value>0, 0, 1, 1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume</value></param>
<param><key>value</key><value>.3</value></param>
<param><key>gui_hint</key><value>1, 0, 1, 1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>.1</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>analog_agc3_xx</key>
<param><key>id</key><value>analog_agc3_xx_0</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>iir_update_decim</key><value>1</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>reference</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>audio_decim</key><value>audio_dec</value></param>
<param><key>audio_pass</key><value>5e3</value></param>
<param><key>audio_stop</key><value>5.5e3</value></param>
<param><key>chan_rate</key><value>48e3</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>passband*1000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate/decimate</value></param>
<param><key>width</key><value>transition</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0 ,5, 4</value></param>
<param><key>name</key><value>Raw From RSP1A</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate/decimate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>8, 0, 5, 4</value></param>
<param><key>name</key><value>After Low Pass Filter</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>13, 0, 5, 4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Audio Signal</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>48e3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>decimate</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>decim</key><value>16</value></param>
<param><key>interp</key><value>12</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>sdrplay_rsp1a_source</key>
<param><key>id</key><value>sdrplay_rsp1a_source_0</value></param>
<param><key>agc_enabled</key><value>False</value></param>
<param><key>bw</key><value>1536</value></param>
<param><key>biasT</key><value>False</value></param>
<param><key>bcast_notch</key><value>False</value></param>
<param><key>dab_notch</key><value>False</value></param>
<param><key>dc_offset_mode</key><value>True</value></param>
<param><key>debug_enabled</key><value>False</value></param>
<param><key>device_serial</key><value>'0'</value></param>
<param><key>if_atten_db</key><value>1</value></param>
<param><key>ifType</key><value>0</value></param>
<param><key>iq_balance_mode</key><value>True</value></param>
<param><key>lna_atten_step</key><value>0</value></param>
<param><key>lo_mode</key><value>1</value></param>
<param><key>rf_freq</key><value>freq</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>analog_agc3_xx_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>analog_agc3_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1a_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sdrplay_rsp1a_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
